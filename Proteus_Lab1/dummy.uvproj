# Keil uVision project dummy.uvproj, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output.elf +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --feedback=filename
  c include: .\src\;.\src\CMSIS\CM3\CoreSupport;.\src\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\src\STM32F10x_StdPeriph_Driver\inc;.\src\STM32F10x_StdPeriph_Driver\src;.\src\STM32F10x_StdPeriph_Driver;.\src\functions\inc;.\src\functions
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  link misc: --feedback=filename
  group main
    ./src/main/: main.c
  group debug
    ./src/functions/src/: debug.c
  group systick
    ./src/functions/src/: systick.c
  group motor_voltage
    ./src/functions/src/: motor_voltage.c
  group motor_speed
    ./src/functions/src/: motor_speed.c
  group control
    ./src/functions/src/: control.c
  group cmsis
    ./src/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./src/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c stm32f10x.h
    ./src/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group std_periph_lib
    ./src/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
    ./src/STM32F10x_StdPeriph_Driver/: stm32f10x_conf.h
