# Keil uVision project dummy.uvproj, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103T6 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: dummy +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103x6, USE_FULL_ASSERT, STM32F10X_LD, HSE_VALUE=8000000, USE_STDPERIPH_DRIVER,
  c misc: --c99 --feedback=file_name
  c include: .\src\cmsis;.\src;.\src\mcu_support_package\inc;.\src\spl;.\src\spl\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  link misc: --feedback=file_name
  group main
    ./src/main/: main.c
  group mcu_support_package
    ./src/mcu_support_package/: system_stm32f10x.c
    ./src/mcu_support_package/arm/: startup_stm32f103x6.s
    ./src/mcu_support_package/inc/: system_stm32f10x.h stm32f10x.h
  group spl
    ./src/spl/src/: stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c
    ./src/spl/inc/: misc.h stm32f10x_adc.h stm32f10x_dma.h stm32f10x_gpio.h stm32f10x_rcc.h
  group motor_voltage
    ./src/main/: motor_voltage.c
  group adc
    ./src/main/: adc.c
  group motor_control
    ./src/main/: motor_regulator.c
  group motor_revert
    ./src/main/: motor_revert.c
